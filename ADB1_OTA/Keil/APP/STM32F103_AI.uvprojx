# Keil uVision project STM32F103_AI.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_AI +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: -Wno-padded -Wno-missing-noreturn -Wno-covered-switch-default -Wno-cast-align
  c include: ..\..\Project\Cold\Driver\inclue;..\..\Project\Cold\AI\inclue;..\..\Project\Cold\Control\inclue;..\..\Project\Cold\GPIO\inclue;..\..\Project\Cold\IOT\inclue;..\..\Project\Cold\Mode\inclue;..\..\Project\Cold\OTA\inclue;..\..\Project\Cold\Player\inclue;..\..\Project\Cold\Time\inclue;..\..\Project\Cold\Usart\inclue;..\..\Project\Cold\WIFI\inclue;..\..\Project\Cold\CMISS\STM32Cube_FW_F1_V1.8.0\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Project\Cold\CMISS\STM32Cube_FW_F1_V1.8.0\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\Project\Cold\CMISS\STM32Cube_FW_F1_V1.8.0\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Project\Cold\CMISS\STM32Cube_FW_F1_V1.8.0\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8004000 size 0xbc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../../Project/: main.c
  group AI
    ../../Project/Cold/AI/src/: app_ai.c
  group Control
    ../../Project/Cold/Control/src/: app_ctrl.c
  group Driver
    ../../Project/Cold/Driver/src/: stm32f1xx_it.c stm32f1xx_hal_msp.c system_stm32f1xx.c
  group GPIO
    ../../Project/Cold/GPIO/src/: gpio.c
  group IOT
    ../../Project/Cold/IOT/src/: app_iot.c
  group Mode
    ../../Project/Cold/Mode/src/: app_modes.c
  group Player
    ../../Project/Cold/Player/src/: app_player.c
  group OTA
    ../../Project/Cold/OTA/src/: app_ota.c
  group Time
    ../../Project/Cold/Time/src/: soft_timer.c system_tick.c
  group Usart
    ../../Project/Cold/Usart/src/: usart.c usart_transport.c
  group WIFI
    ../../Project/Cold/WIFI/src/: ad_sdk.c
  group STM32 HAL
    ../../Project/Cold/CMISS/STM32Cube_FW_F1_V1.8.0/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c
  group CMSIS
    ../../Project/Cold/CMISS/STM32Cube_FW_F1_V1.8.0/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
